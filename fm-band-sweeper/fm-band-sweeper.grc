options:
  parameters:
    author: Vadym Khondar
    generate_options: qt_gui
    id: fm_band_sweeper
    output_language: python
    title: FM band sweeper
  states: {}

blocks:
- name: audio_resampling_fc
  id: variable
  parameters:
    value: '5'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '100300000'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '1102500'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: 'Scan frequency:'
    type: int
    value: freq
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_resampling_fc
    quad_rate: audio_samp_rate * audio_resampling_fc
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TICK")
    period: '1000'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class wrap_in_dict_block(gr.basic_block):
          """
          Custom GNU Radio block that transforms an arbitrary input value 
          into a dictionary with a configurable key name.
          """
          def __init__(self, key_name="value"):
              super().__init__(
                  name="Wrap variable in Dict",
                  in_sig=None,  # No streaming input
                  out_sig=None) # No streaming output
              
              # Store the configurable key name
              self.key_name = key_name
              
              # Register message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              
              # Set the message handler
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
          
          def handle_msg(self, msg):
              """
              Handle incoming messages and transform them into dictionaries
              """
              try:
                  # Check if input is a PMT pair (freq . 1.004e+08)
                  if pmt.is_pair(msg):
                      # Extract the value (cdr) from the pair
                      input_value = pmt.to_python(pmt.cdr(msg))
                  else:
                      # Convert the input message to a Python object
                      input_value = pmt.to_python(msg)
                  
                  # Create dictionary with configurable key and input value
                  output_dict = {self.key_name: input_value}
                  
                  # Convert dictionary back to PMT and send
                  output_msg = pmt.to_pmt(output_dict)
                  self.message_port_pub(pmt.intern("out"), output_msg)
                  
              except Exception as e:
                  print(f"Error in value_to_dict_block: {e}")
          
          def set_key_name(self, key_name):
              """
              Setter for the key name parameter
              """
              self.key_name = key_name
          
          def get_key_name(self):
              """
              Getter for the key name parameter
              """
              return self.key_name
    key_name: '"freq"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class range_sweeper_block(gr.basic_block):
          """
          Custom GNU Radio block that sweeps across a given range with each clock,
          emitting values as messages. Optionally loops when boundary is reached.
          """
          def __init__(self, start_val=0.0, stop_val=100.0, step_val=1.0, should_loop=False, key_name="value"):
              super().__init__(
                  name="Range Sweeper",
                  in_sig=None,  # No streaming input
                  out_sig=None) # No streaming output
              
              # Store sweep parameters
              self.start_val = start_val
              self.stop_val = stop_val
              self.step_val = step_val
              self.should_loop = should_loop
              self.key_name = key_name
              
              # Initialize current position
              self.current_value = self.start_val
              
              # Register message ports
              self.message_port_register_in(pmt.intern("clock"))
              self.message_port_register_out(pmt.intern("out"))
              
              # Set the message handler
              self.set_msg_handler(pmt.intern("clock"), self.handle_clock)
          
          def is_finished(self):
              """
              Check if sweep is finished based on current value and bounds
              """
              if self.step_val > 0:
                  return self.current_value > self.stop_val
              else:
                  return self.current_value < self.stop_val
          
          def handle_clock(self, msg):
              """
              Handle incoming clock messages and emit next sweep value
              """
              try:
                  # If finished and not looping, do nothing
                  if self.is_finished() and not self.should_loop:
                      return
                  
                  # If finished and looping, reset to start
                  if self.is_finished() and self.should_loop:
                      self.current_value = self.start_val
                  
                  # Emit current value as PMT pair (key . value)
                  key_pmt = pmt.intern(self.key_name)
                  value_pmt = pmt.to_pmt(self.current_value)
                  output_msg = pmt.cons(key_pmt, value_pmt)
                  self.message_port_pub(pmt.intern("out"), output_msg)
                  
                  # Advance to next value
                  self.current_value += self.step_val
                      
              except Exception as e:
                  print(f"Error in range_sweeper_block: {e}")
          
          def reset_sweep(self):
              """
              Reset the sweep to the beginning
              """
              self.current_value = self.start_val
          
          # Parameter getters and setters
          def set_start_val(self, start_val):
              self.start_val = start_val
              if self.current_value < start_val or self.current_value > self.stop_val:
                  self.reset_sweep()
          
          def get_start_val(self):
              return self.start_val
          
          def set_stop_val(self, stop_val):
              self.stop_val = stop_val
              if self.current_value > stop_val or self.current_value < self.start_val:
                  self.reset_sweep()
          
          def get_stop_val(self):
              return self.stop_val
          
          def set_step_val(self, step_val):
              self.step_val = step_val
              # Prevent zero step to avoid infinite loop
              if step_val == 0:
                  self.step_val = 1.0
          
          def get_step_val(self):
              return self.step_val
          
          def set_should_loop(self, should_loop):
              self.should_loop = should_loop
          
          def get_should_loop(self):
              return self.should_loop
          
          def set_key_name(self, key_name):
              self.key_name = key_name
          
          def get_key_name(self):
              return self.key_name
          
          def get_current_value(self):
              return self.current_value
    key_name: '"value"'
    should_loop: 'True'
    start_val: '85000000'
    step_val: '2000000'
    stop_val: '108000000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0
    name: FM Band scan
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '2'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '100300000'
    samp_rate: rf_samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, clock]
- [blocks_var_to_msg_0, msgout, epy_block_0, in]
- [epy_block_0, out, soapy_rtlsdr_source_0, cmd]
- [epy_block_1, out, blocks_message_debug_0, log]
- [epy_block_1, out, blocks_msgpair_to_var_0, inpair]
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
