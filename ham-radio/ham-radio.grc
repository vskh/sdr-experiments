options:
  parameters:
    description: HAM Radio Receiver with RTL-SDR v4
    generate_options: qt_gui
    id: ham_radio_sdr
    output_language: python
    title: HAM Radio SDR Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: Audio output sample rate
    value: '44100'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    comment: Filter Bandwidth Control
    gui_hint: 1,0,1,1
    label: Filter BW (kHz)
    start: '5000'
    step: '1000'
    stop: '50000'
    value: '15000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: HAM Radio 2m Band 144-148MHz
    gui_hint: 0,0,1,2
    label: HAM Frequency (MHz)
    start: '144000000'
    step: '25000'
    stop: '148000000'
    value: '146000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: RTL-SDR RF Gain
    gui_hint: 0,2,1,1
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '49.6'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RTL-SDR sampling rate - wider for scanning
    value: '2048000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Audio Volume Control
    gui_hint: 0,3,1,1
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    comment: NBFM Demodulator for HAM
    max_dev: '5000'
    quad_rate: '44100'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Audio Output 44.1kHz
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume Control
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Variable bandwidth filter
    cutoff_freq: bandwidth
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bandwidth/3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Domain Display
    fc: freq
    fftsize: '2048'
    gui_hint: 2,0,1,2
    name: '"Frequency Spectrum"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Waterfall Display
    fc: freq
    fftsize: '2048'
    gui_hint: 2,2,1,2
    name: '"Waterfall"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Downsample for NBFM
    decim: '46'
    interp: '1'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    comment: RTL-SDR v4 Source
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
