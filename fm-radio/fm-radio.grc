options:
  parameters:
    description: SDR FM Radio Receiver with RTL-SDR v4
    generate_options: qt_gui
    id: fm_radio_sdr
    output_language: python
    title: FM Radio SDR Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: Audio output sample rate
    value: '44100'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: FM Frequency Range 85-108MHz
    gui_hint: 0,0,1,2
    label: FM Frequency (MHz)
    start: '85000000'
    step: '100000'
    stop: '108000000'
    value: '95500000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: RTL-SDR RF Gain
    gui_hint: 0,2,1,1
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '49.6'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RTL-SDR sampling rate >2MS/s
    value: '2400000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Audio Volume Control
    gui_hint: 0,3,1,1
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    comment: WBFM Demodulator
    quad_rate: '240000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Audio Output 44.1kHz
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume Control
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: 100kHz cutoff, 50kHz width
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Domain Display
    fc: freq
    fftsize: '2048'
    gui_hint: 1,0,1,2
    name: '"Frequency Spectrum"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Waterfall Display
    fc: freq
    fftsize: '2048'
    gui_hint: 1,2,1,2
    name: '"Waterfall"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Downsample for WBFM
    decim: '10'
    interp: '1'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    comment: RTL-SDR v4 Source
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
