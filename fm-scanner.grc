options:
  parameters:
    author: Vadym
    description: Sweeps 88–108 MHz with RTL-SDR and displays rolling waterfall
    generate_options: qt_gui
    id: fm_band_sweep_waterfall
    output_language: python
    title: FM Band Sweeping Waterfall
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for RTL-SDR
    value: '2400000'
  states: {}
- name: current_freq
  id: variable_qtgui_range
  parameters:
    comment: Current frequency for manual control
    gui_hint: 0,0,1,2
    label: Current Freq (MHz)
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '95500000'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: current_freq
    comment: RTL-SDR v4 Source
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Waterfall Display for FM Band
    fc: current_freq
    fftsize: '1024'
    gui_hint: 1,0,1,2
    name: '"FM Band Waterfall"'
    type: complex
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
